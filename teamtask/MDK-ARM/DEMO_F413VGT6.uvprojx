# Keil uVision project DEMO_F413VGT6.uvprojx, settings and files
target DEMO_F413VGT6 (6090000::V6.9::.\ARMCLANG)
  device: STM32F413VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: DEMO_F413VGT6 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F413xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Basic;../Communication;../Control;../Motor;../Parameter;../Sensor;../Upper_action;../MDK-ARM;../bezier;../Remote;..\task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f413xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Communication
    ../Communication/: can_database.c
  group Control
    ../Control/: debug.c pid.c
  group Upper_action
    ../Upper_action/: basic_action.c
  group Basic
    ../Basic/: basic.c
  group Motor
    ../Motor/: dji_motor.c angle.c pan.c angle.h dji_motor.h pan.h vesc.c vesc.h
  group bezier
    ../bezier/: bezier.c calculate_angle.c get_abs.c bezier.h calculate_angle.h get_abs.h
  group Remote
    ../Remote/: remote.c
  group Task
    ../task/: task1.c task1.h
software components: CMSIS:CORE 5.6.0
